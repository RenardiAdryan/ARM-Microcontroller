# Keil uVision project USART Interupt.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART Interupt
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER HSE_VALUE=8000000
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c delay.c lcd16x2.c config.c
  group header
    ./: delay.h lcd16x2.h config.h
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
